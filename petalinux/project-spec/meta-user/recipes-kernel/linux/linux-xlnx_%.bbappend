FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://user.cfg"
